# IAR project at91sam7s-ek.ewp, settings and files
configuration at91sam7s128_flash (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7s128 Atmel at91sam7s128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam7s128; flash; TRACE_LEVEL=3
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib/usb/device; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam7s-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7s128; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7s-ek
  OBJCOPY.OOCOutputFile: at91sam7s128_flash.bin
  ILINK.IlinkOutputFile: at91sam7s128_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s128\flash
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7s128_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7s128; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s128; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s128_sram.bin
  ILINK.IlinkOutputFile: at91sam7s128_sram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s128\sram
configuration at91sam7s256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s256 Atmel at91sam7s256
  ICCARM.CCDefines: at91sam7s256; flash; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\at91lib/peripherals; ..\..\at91lib/components; ..\..\at91lib/usb/device; ..\..\at91lib; ..\..\at91lib/boards/at91sam7s-ek; ..\..\app
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: at91sam7s256; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam7s-ek
  OBJCOPY.OOCOutputFile: at91sam7s256_flash.bin
  ILINK.IlinkOutputFile: at91sam7s256_flash.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7s-ek\at91sam7s256\flash
configuration at91sam7s256_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s256 Atmel at91sam7s256
  ICCARM.CCDefines: at91sam7s256; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s256; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s256_sram.bin
  ILINK.IlinkOutputFile: at91sam7s256_sram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s256\sram
configuration at91sam7s321_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s321 Atmel at91sam7s321
  ICCARM.CCDefines: at91sam7s321; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s321; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s321_flash.bin
  ILINK.IlinkOutputFile: at91sam7s321_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s321\flash
configuration at91sam7s512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s512 Atmel at91sam7s512
  ICCARM.CCDefines: at91sam7s512; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s512; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s512_flash.bin
  ILINK.IlinkOutputFile: at91sam7s512_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s512\flash
configuration at91sam7s512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s512 Atmel at91sam7s512
  ICCARM.CCDefines: at91sam7s512; sram; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s512; sram; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s512_sram.bin
  ILINK.IlinkOutputFile: at91sam7s512_sram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s512\sram
configuration at91sam7s64_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7s64 Atmel at91sam7s64
  ICCARM.CCDefines: at91sam7s64; flash; TRACE_LEVEL=3
  AARM.ADefines: at91sam7s64; flash; TRACE_LEVEL=3
  OBJCOPY.OOCOutputFile: at91sam7s64_flash.bin
  ILINK.IlinkOutputFile: at91sam7s64_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7s-ek\at91sam7s64\flash
configuration at91sam7x256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: at91sam7x256; flash; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ..\..\at91lib/peripherals; ..\..\at91lib/components; ..\..\at91lib/usb/device; ..\..\at91lib; ..\..\at91lib/boards/at91sam7x-ek; ..\..\app
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: at91sam7x256; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\..\at91lib; ..\..\at91lib\peripherals; ..\..\at91lib\boards\at91sam7x-ek
  OBJCOPY.OOCOutputFile: Bridge_Audio_Dev_FW_V.bin
  ILINK.IlinkOutputFile: at91sam7x256_flash.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7x-ek\at91sam7x256\flash
configuration at91sam7x512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM7X512 Atmel AT91SAM7X512
  ICCARM.CCDefines: at91sam7x512; flash; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: at91sam7x512; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Bridge_Audio_Dev_FW_V.bin
  ILINK.IlinkOutputFile: at91sam7x512_flash.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7x-ek\at91sam7x512\flash
  group .
    ../../../at91sam7s-ek/: usb-device-cdc-serial-project
  group at91lib/boards/at91sam7x-ek
    ../../at91lib/boards/at91sam7x-ek/: board_cstartup_iar.s board_lowlevel.c board_memories.c
  group at91lib/boards/at91sam7x-ek/at91sam7x512
    ../../at91lib/boards/at91sam7x-ek/at91sam7x512/: AT91SAM7X512.h chip.h flash.icf sram.icf
  group at91lib/peripherals/cp15
    ../../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../../at91lib/peripherals/irq/: aic.c irq.h
  group at91lib/peripherals/pio
    ../../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/ssc
    ../../at91lib/peripherals/ssc/: ssc.c ssc.h
  group at91lib/peripherals/tc
    ../../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/peripherals/usart
    ../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/usb/common/audio
    ../../at91lib/usb/common/audio/: AUDControlInterfaceDescriptor.h AUDDataEndpointDescriptor.h AUDEndpointDescriptor.h AUDFeatureUnitDescriptor.h AUDFeatureUnitRequest.c AUDFeatureUnitRequest.h AUDFormatTypeOneDescriptor.h AUDGenericDescriptor.h AUDGenericRequest.c AUDGenericRequest.h AUDHeaderDescriptor.h AUDInputTerminalDescriptor.h AUDOutputTerminalDescriptor.h AUDStreamingInterfaceDescriptor.h
  group at91lib/usb/common/core
    ../../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceAssociationDescriptor.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/usb/device/audio_speaker
    ../../at91lib/usb/device/audio-speaker/: AUDDSpeakerChannel.c AUDDSpeakerDriver.c AUDDSpeakerDriverDescriptors.c
  group at91lib/usb/device/core
    ../../at91lib/usb/device/core/: USBD.h USBD_UDP.c USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCallbacks_ConfigurationChanged.c USBDDriverDescriptors.h
  group at91lib/utility
    ../../at91lib/utility/: assert.h led.c led.h trace.c trace.h
  group documentation
    ../: ewinfo.ENU.html ExampleInfo.ENU.xml
  group resources
    ../../resource/: at91sam7x-ek-flash.mac at91sam7x-ek-sram.mac
  group usb-device-cdc-serial-project
    ../: main.c
  group usb-device-cdc-serial-project/app
    ../../app/: app.c I2s.c ioSyn.c uart.c usb.c
